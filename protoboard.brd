File: protoboard.brd (EAGLE design)
At the start: 102.9 x 52.1 mm, 0 parts

Commit message: 2"x4" board size
Other:
- board size 102.9 x 52.1 mm -> 101.6 x 50.8 mm
